# IAR project runbootloader.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MCXN947/utilities/str; ../../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../../devices/MCXN947/drivers/romapi/mem_interface; ../../../../../../../devices/MCXN947/drivers/romapi/flash; ../../../../../../../devices/MCXN947/drivers/romapi/nboot; ../../../../../../../devices/MCXN947/drivers/romapi/runbootloader; ../../../../../../../devices/MCXN947/drivers; ../../../../../../../devices/MCXN947; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: runbootloader.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: runbootloader.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group drivers/mem_interface
    ../../../../../../../devices/MCXN947/drivers/romapi/mem_interface/: fsl_mem_interface.h fsl_sbloader.h fsl_sbloader_v3.h
  group drivers/flash
    ../../../../../../../devices/MCXN947/drivers/romapi/flash/: fsl_flash.h fsl_flash_ffr.h fsl_flexspi_nor_flash.h
  group drivers/nboot
    ../../../../../../../devices/MCXN947/drivers/romapi/nboot/: fsl_nboot.h fsl_nboot_hal.h
  group drivers/runbootloader
    ../../../../../../../devices/MCXN947/drivers/romapi/runbootloader/: fsl_runbootloader.h
  group drivers/runbootloader/src
    ../../../../../../../devices/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
