# IAR project cmsis_lpi2c_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../../../devices/MCXN947/utilities/str; ../../../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../../../devices/MCXN947/drivers; ../../../../../../../../devices/MCXN947/cmsis_drivers; ../../../../../../../../devices/MCXN947; ../../../../../../../../components/uart; ../../../../../../../../components/lists; ../../../../../../../../CMSIS/Core/Include; ../../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_lpi2c_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_lpi2c_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../../devices/MCXN947/drivers/: fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_lpi2c_edma.h fsl_lpi2c_edma.c fsl_port.h fsl_clock.h fsl_clock.c fsl_lpi2c.h fsl_lpi2c.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_edma_soc.h fsl_edma_soc.c
    ../../../../../../../../devices/MCXN947/cmsis_drivers/: fsl_lpi2c_cmsis.h fsl_lpi2c_cmsis.c
  group device
    ../../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS_driver
    ../../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
