# IAR project freertos_message_buffers_cm33_core1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core1 NXP MCXN947_core1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core1; MULTICORE_APP=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../devices/MCXN947/drivers; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../devices/MCXN947; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; SLAVEBOOT; NO_CRP
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_message_buffers_cm33_core1.out
  ILINK.IlinkConfigDefines: __use_shmem__=1
  ILINK.IlinkIcfFile: MCXN947_cm33_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core1; MULTICORE_APP=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; SLAVEBOOT; NO_CRP
  group source
    ../: main_remote.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_mcxnx4x.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_mailbox.h fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core1.h MCXN947_cm33_core1_features.h system_MCXN947_cm33_core1.c system_MCXN947_cm33_core1.h
  group startup
    ../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core1.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
