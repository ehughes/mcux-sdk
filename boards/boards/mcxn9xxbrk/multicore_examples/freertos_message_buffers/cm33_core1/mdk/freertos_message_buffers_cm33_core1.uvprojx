# Keil uVision project freertos_message_buffers_cm33_core1.uvprojx, settings and files
target freertos_message_buffers_cm33_core1 debug (ARM-ADS)
  device: MCXN947VDF:cm33_core1 NXP
  pack: NXP.MCXN947_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_message_buffers_cm33_core1.out
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x2004E000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core1, MULTICORE_APP=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXN947/utilities/str;../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../devices/MCXN947/drivers;../../../../../../middleware/multicore/mcmgr/src;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../devices/MCXN947;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL, DEBUG, SLAVEBOOT, NO_CRP
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x14000000 size 0x18000
  memory RVCT7: RAM 0x30000000 size 0x68000
  memory RVCT8: RAM 0x400ba000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x68000
  memory RVCT10: RAM 0x4000000 size 0x18000
  scatter file: MCXN947_cm33_core1_ram.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__use_shmem__=1"
  group source
    ../: main_remote.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mcmgr
    ../../../../../../middleware/multicore/mcmgr/src/: mcmgr_internal_core_api_mcxnx4x.c mcmgr.h mcmgr_internal_core_api.h mcmgr.c
  group utilities
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_mailbox.h fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core1.h MCXN947_cm33_core1_features.h system_MCXN947_cm33_core1.c system_MCXN947_cm33_core1.h
  group startup
    ../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core1.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target freertos_message_buffers_cm33_core1 release (ARM-ADS)
  device: MCXN947VDF:cm33_core1 NXP
  pack: NXP.MCXN947_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: freertos_message_buffers_cm33_core1.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core1, MULTICORE_APP=1, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL, NDEBUG, SLAVEBOOT, NO_CRP
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: ROM 0x14000000 size 0x18000
  memory RVCT7: ROM 0x30000000 size 0x68000
  memory RVCT8: ROM 0x400ba000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x68000
  memory RVCT10: RAM 0x4000000 size 0x18000
  scatter file: MCXN947_cm33_core1_ram.scf
  link misc: as above
