# IAR project dev_mtp_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MCXN947VDF_cm33_core0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_BM; SD_ENABLED; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ../../../../..; ../..; ..; ../../../../../../../middleware/usb/device; ../../../../../../../middleware/usb/include; ../../../../../../../middleware/usb/phy; ../../../../../../../devices/MCXN947/drivers; ../../../../../../../middleware/sdmmc/sd; ../../../../../../../middleware/sdmmc/common; ../../../../../../../middleware/sdmmc/host/usdhc; ../../../../../../../components/gpio; ../../../../../../../middleware/fatfs/source; ../../../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../../../devices/MCXN947; ../../../../../../../devices/MCXN947/utilities/str; ../../../../../../../devices/MCXN947/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../components/osa; ../../../../../../../CMSIS/Core/Include; ../../../../../../../middleware/sdmmc/osa
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_mtp_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x100
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MCXN947VDF_cm33_core0; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; USB_STACK_BM; SD_ENABLED; FSL_OSA_BM_TASK_ENABLE=0; FSL_OSA_BM_TIMER_CONFIG=0; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: sdmmc_config.c sdmmc_config.h board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group source
    ../../: ffconf.h
    ../: mtp.c mtp.h mtp_operation.c mtp_operation.h mtp_file_system_adapter.c mtp_file_system_adapter.h mtp_object_handle.c mtp_object_handle.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group doc
    ../: readme.txt
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/source/ehci
    ../../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/mtp
    ../: usb_device_mtp.c usb_device_mtp.h usb_device_mtp_operation.c usb_device_mtp_operation.h
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_usdhc.c fsl_usdhc.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group sdmmc/src
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group sdmmc/inc
    ../../../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../../../middleware/sdmmc/common/: fsl_sdmmc_spec.h fsl_sdmmc_common.h
  group sdmmc/sd
    ../../../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/host
    ../../../../../../../middleware/sdmmc/host/usdhc/: fsl_sdmmc_host.h ChangeLogKSDK.txt fsl_sdmmc_host.h ChangeLogKSDK.txt
    ../../../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/osa
    ../../../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.h fsl_sdmmc_osa.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.c
  group fatfs/source
    ../../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group utilities
    ../../../../../../../devices/MCXN947/utilities/: fsl_assert.c
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
