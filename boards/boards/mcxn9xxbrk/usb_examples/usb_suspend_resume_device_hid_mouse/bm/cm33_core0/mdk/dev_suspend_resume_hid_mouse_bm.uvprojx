# Keil uVision project dev_suspend_resume_hid_mouse_bm.uvprojx, settings and files
target dev_suspend_resume_hid_mouse_bm debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_suspend_resume_hid_mouse_bm.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_MCXN947VDF_cm33_core0, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../middleware/usb/device;../../../../../../../middleware/usb/include;../../../../../../../middleware/usb/phy;../../../../../../../components/timer;../../../../../../../components/gpio;../../../../../../../devices/MCXN947/drivers;../../../../../../../devices/MCXN947/utilities/str;../../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../../devices/MCXN947;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../components/osa;../../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x2000"
  group doc
    ../: readme.txt
  group source
    ../: mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/include
    ../../../../../../../middleware/usb/include/: usb.h usb.h usb_misc.h usb_spec.h
  group usb/device/source/ehci
    ../../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/phy
    ../../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group component/timer
    ../../../../../../../components/timer/: fsl_adapter_timer.h fsl_adapter_mrt.c
  group component/gpio
    ../../../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_gpio.c
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_reset.h fsl_reset.c fsl_mrt.h fsl_mrt.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group utilities
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h usb_device_dci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group usb/device/include
    ../../../../../../../middleware/usb/device/: usb_device.h usb_device.h
  group component/osa
    ../../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target dev_suspend_resume_hid_mouse_bm release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: dev_suspend_resume_hid_mouse_bm.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_MCXN947VDF_cm33_core0, USB_STACK_BM, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: as above
