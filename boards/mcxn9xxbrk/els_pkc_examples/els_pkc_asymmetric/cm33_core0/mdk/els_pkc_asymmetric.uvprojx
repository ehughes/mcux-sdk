# Keil uVision project els_pkc_asymmetric.uvprojx, settings and files
target els_pkc_asymmetric debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: els_pkc_asymmetric.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXN947/utilities/str;../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../components/els_pkc;../../../../../../components/els_pkc/src/inc;../../../../../../components/els_pkc/src/inc/impl;../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/ex/inc;../../../../../../components/els_pkc/src/comps/mcuxClExample/inc;../../../../../../devices/MCXN947/drivers;../../../../../../devices/MCXN947;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/Core/Include;../../../../../../components/els_pkc/src/platforms/nirvanaSdk;../../../../../../components/els_pkc/src/platforms/nirvanaSdk/inc;../../../../../../components/els_pkc/src/comps/mcuxClEls;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc;../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc;../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc;../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc;../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc;../../../../../../components/els_pkc/src/platforms;../../../../../../components/els_pkc/src/compiler;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc;../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc;../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc;../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc;../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClMath/inc;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc;../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCore/inc;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc;../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc;../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc;../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal;../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc;../../../../../../components/els_pkc/src/comps/common/inc
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x2000"
  group source
    ../: els_pkc_asymmetric.c els_pkc_asymmetric.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group component/els_pkc/src/inc
    ../../../../../../components/els_pkc/src/inc/: mcuxCl_clns.h
  group component/els_pkc/src/inc/impl
    ../../../../../../components/els_pkc/src/inc/impl/: mcuxCl_clns_impl.h
  group component/els_pkc/examples/mcuxClAeadModes
    ../../../../../../components/els_pkc/examples/mcuxClAeadModes/: mcuxClAeadModes_multiPart_ELS_CCM_example.c mcuxClAeadModes_oneshot_ELS_CCM_example.c mcuxClAeadModes_oneshot_ELS_GCM_example.c
  group component/els_pkc/examples/mcuxClCipherModes
    ../../../../../../components/els_pkc/examples/mcuxClCipherModes/: mcuxClCipherModes_CBC_Multipart_ELS_example.c mcuxClCipherModes_CBC_Oneshot_ELS_example.c mcuxClCipherModes_CBC_Oneshot_Padding_ELS_example.c mcuxClCipherModes_CTR_Multipart_ELS_example.c mcuxClCipherModes_CTR_Oneshot_ELS_example.c mcuxClCipherModes_ECB_Multipart_ELS_example.c mcuxClCipherModes_ECB_Oneshot_ELS_example.c mcuxClCipherModes_ECB_Oneshot_Padding_ELS_example.c
  group component/els_pkc/examples/mcuxClEcc
    ../../../../../../components/els_pkc/examples/mcuxClEcc/: mcuxClEcc_EdDSA_Ed25519_example.c mcuxClEcc_EdDSA_GenerateKeyPair_Ed25519_example.c mcuxClEcc_Mont_Curve448_example.c mcuxClEcc_Mont_Curve25519_example.c mcuxClEcc_WeierECC_CustomEccWeierType_BN256_example.c
  group component/els_pkc/examples/mcuxClEls
    ../../../../../../components/els_pkc/examples/mcuxClEls/: cipher_aes128_cbc_encrypt.c cipher_aes128_ecb_encrypt.c ckdf_aes_128_ecb_encrypt.c common_get_info.c ecc_keygen_sign_verify.c hash_sha224_one_block.c hash_sha256_one_block.c hash_sha384_one_block.c hash_sha512_one_block.c key_import_puk_der.c rng_prng_get_random.c tls_master_key_session_keys.c
  group component/els_pkc/examples/mcuxClHash
    ../../../../../../components/els_pkc/examples/mcuxClHash/: mcuxClHash_sha224_oneshot_example.c mcuxClHash_sha256_longMsgOneshot_example.c mcuxClHash_sha256_oneshot_example.c mcuxClHash_sha256_streaming_example.c mcuxClHash_sha384_oneshot_example.c mcuxClHash_sha512_oneshot_example.c
  group component/els_pkc/examples/mcuxClKey
    ../../../../../../components/els_pkc/examples/mcuxClKey/: mcuxClKey_example.c
  group component/els_pkc/examples/mcuxClMacModes
    ../../../../../../components/els_pkc/examples/mcuxClMacModes/: mcuxClMacModes_cbc_mac_multipart_zero_padding_example.c mcuxClMacModes_cbc_mac_oneshot_example.c mcuxClMacModes_cmac_oneshot_example.c mcuxClMacModes_cmac_oneshot_internal_ckdf_key_example.c mcuxClMacModes_cmac_oneshot_internal_key_example.c mcuxClMacModes_hmac_oneshot_external_key_example.c mcuxClMacModes_hmac_oneshot_internal_key_example.c
  group component/els_pkc/examples/mcuxClOsccaSm3
    ../../../../../../components/els_pkc/examples/mcuxClOsccaSm3/: mcuxClOsccaSm3_oneshot_example.c mcuxClOsccaSm3_streaming_example.c
  group component/els_pkc/examples/mcuxClRandomModes
    ../../../../../../components/els_pkc/examples/mcuxClRandomModes/: mcuxClRandomModes_CtrDrbg_AES256_DRG3_example.c mcuxClRandomModes_CtrDrbg_AES256_DRG4_example.c mcuxClRandomModes_CtrDrbg_AES256_ELS_example.c mcuxClRandomModes_ELS_example.c
  group component/els_pkc/examples/mcuxClRsa
    ../../../../../../components/els_pkc/examples/mcuxClRsa/: mcuxClRsa_sign_NoEncode_example.c mcuxClRsa_sign_pss_sha2_256_example.c mcuxClRsa_verify_NoVerify_example.c mcuxClRsa_verify_pssverify_sha2_256_example.c
  group component/els_pkc/examples/mcuxCsslFlowProtection
    ../../../../../../components/els_pkc/examples/mcuxCsslFlowProtection/: mcuxCsslFlowProtection_example.c
  group component/els_pkc/examples/mcuxCsslMemory
    ../../../../../../components/els_pkc/examples/mcuxCsslMemory/: data_invariant_memory_compare.c data_invariant_memory_copy.c
  group component/els_pkc/src/comps/mcuxClExample/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClExample/inc/: mcuxClExample_ELS_Helper.h mcuxClExample_ELS_Key_Helper.h mcuxClExample_Key_Helper.h mcuxClExample_RFC3394_Helper.h mcuxClExample_RNG_Helper.h mcuxClExample_Session_Helper.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/ex/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/ex/inc/: mcuxCsslExamples.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/els_pkc/src/platforms/nirvanaSdk
    ../../../../../../components/els_pkc/src/platforms/nirvanaSdk/: mcuxClConfig.h platform_specific_headers.h
  group component/els_pkc/src/platforms/nirvanaSdk/inc
    ../../../../../../components/els_pkc/src/platforms/nirvanaSdk/inc/: ip_css_constants.h ip_css_design_configuration.h ip_platform.h
  group component/els_pkc/src/comps/mcuxClEls/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Aead.c mcuxClEls_Cipher.c mcuxClEls_Cmac.c mcuxClEls_Common.c mcuxClEls_Crc.c mcuxClEls_Ecc.c mcuxClEls_Hash.c mcuxClEls_Hmac.c mcuxClEls_Kdf.c mcuxClEls_KeyManagement.c mcuxClEls_Rng.c
  group component/els_pkc/src/comps/mcuxClEls/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/: mcuxClEls.h mcuxClEls_Aead.h mcuxClEls_Cipher.h mcuxClEls_Cmac.h mcuxClEls_Common.h mcuxClEls_Crc.h mcuxClEls_Ecc.h mcuxClEls_Hash.h mcuxClEls_Hmac.h mcuxClEls_Kdf.h mcuxClEls_KeyManagement.h mcuxClEls_mapping.h mcuxClEls_Rng.h mcuxClEls_Types.h
  group component/els_pkc/src/comps/mcuxClEls/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEls/inc/internal/: mcuxClEls_Internal.h mcuxClEls_Internal_mapping.h mcuxClEls_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClHash/src
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/src/: mcuxClHash_api_multipart_common.c mcuxClHash_api_multipart_compute.c mcuxClHash_api_oneshot_compute.c mcuxClHash_core_els_sha2.c mcuxClHash_internal_els_sha2.c
  group component/els_pkc/src/comps/mcuxClHash/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClHash/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/: mcuxClHash.h mcuxClHash_Algorithms.h mcuxClHash_Constants.h mcuxClHash_Functions.h mcuxClHash_MemoryConsumption.h mcuxClHash_Types.h
  group component/els_pkc/src/comps/mcuxClHash/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClHash/inc/internal/: mcuxClHash_Core_els_sha2.h mcuxClHash_Internal.h mcuxClHash_Internal_els_sha2.h mcuxClHash_Internal_Memory.h
  group component/els_pkc/src/comps/mcuxClSession/src
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/src/: mcuxClSession.c
  group component/els_pkc/src/comps/mcuxClSession/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/: mcuxClSession.h mcuxClSession_Functions.h mcuxClSession_Types.h
  group component/els_pkc/src/comps/mcuxClSession/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClSession/inc/internal/: mcuxClSession_Internal.h
  group component/els_pkc/src/comps/mcuxCsslFlowProtection/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslFlowProtection/inc/: mcuxCsslFlowProtection.h mcuxCsslFlowProtection_Cfg.h mcuxCsslFlowProtection_FunctionIdentifiers.h mcuxCsslFlowProtection_Impl.h mcuxCsslFlowProtection_SecureCounter_Common.h mcuxCsslFlowProtection_SecureCounter_Local.h
  group component/els_pkc/src/comps/mcuxCsslSecureCounter/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslSecureCounter/inc/: mcuxCsslSecureCounter.h mcuxCsslSecureCounter_Cfg.h mcuxCsslSecureCounter_Impl.h mcuxCsslSecureCounter_None.h mcuxCsslSecureCounter_SW_Local.h
  group component/els_pkc/src/comps/mcuxCsslCPreProcessor/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslCPreProcessor/inc/: mcuxCsslAnalysis.h mcuxCsslCPreProcessor.h
  group component/els_pkc/src/comps/mcuxClMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
  group component/els_pkc/src/comps/mcuxClMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/: mcuxClMemory.h mcuxClMemory_Clear.h mcuxClMemory_Copy.h mcuxClMemory_Endianness.h mcuxClMemory_Set.h mcuxClMemory_Types.h
  group component/els_pkc/src/comps/mcuxClMemory/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMemory/inc/internal/: mcuxClMemory_Copy_Internal.h
  group component/els_pkc/src/comps/mcuxCsslMemory/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
  group component/els_pkc/src/comps/mcuxCsslMemory/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslMemory/inc/: mcuxCsslMemory.h mcuxCsslMemory_Clear.h mcuxCsslMemory_Compare.h mcuxCsslMemory_Compare_asm.h mcuxCsslMemory_Copy.h mcuxCsslMemory_Copy_asm.h mcuxCsslMemory_Set.h mcuxCsslMemory_Types.h
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/src
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity.c
  group component/els_pkc/src/comps/mcuxCsslParamIntegrity/inc
    ../../../../../../components/els_pkc/src/comps/mcuxCsslParamIntegrity/inc/: mcuxCsslParamIntegrity.h
  group component/els_pkc/src/platforms
    ../../../../../../components/els_pkc/src/platforms/: mcux_els.c mcux_els.h mcux_pkc.c mcux_pkc.h
  group component/els_pkc/src/compiler
    ../../../../../../components/els_pkc/src/compiler/: toolchain.h
  group component/els_pkc/src/comps/mcuxClKey/src
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/src/: mcuxClKey.c mcuxClKey_KeyTypes.c mcuxClKey_Protection.c
  group component/els_pkc/src/comps/mcuxClKey/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClKey/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/: mcuxClKey.h mcuxClKey_Constants.h mcuxClKey_Functions.h mcuxClKey_KeyTypes.h mcuxClKey_MemoryConsumption.h mcuxClKey_ProtectionMechanisms.h mcuxClKey_Types.h
  group component/els_pkc/src/comps/mcuxClKey/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClKey/inc/internal/: mcuxClKey_Functions_Internal.h mcuxClKey_Internal.h mcuxClKey_Protection_Internal.h mcuxClKey_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClMac/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/src/: mcuxClMac.c
  group component/els_pkc/src/comps/mcuxClMac/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/: mcuxClMac.h mcuxClMac_Constants.h mcuxClMac_Functions.h mcuxClMac_Types.h
  group component/els_pkc/src/comps/mcuxClMac/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMac/inc/internal/: mcuxClMac_Ctx.h mcuxClMac_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClAes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/src/: mcuxClAes_KeyTypes.c
  group component/els_pkc/src/comps/mcuxClAes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/: mcuxClAes_KeyTypes.h mcuxClAes_Constants.h mcuxClAes.h
  group component/els_pkc/src/comps/mcuxClAes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAes/inc/internal/: mcuxClAes_Ctx.h mcuxClAes_Internal_Functions.h mcuxClAes_Internal_Constants.h mcuxClAes_Wa.h
  group component/els_pkc/src/comps/mcuxClPrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/src/: mcuxClPrng_ELS.c
  group component/els_pkc/src/comps/mcuxClPrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPrng/inc/internal/: mcuxClPrng_Internal.h mcuxClPrng_Internal_Constants.h mcuxClPrng_Internal_Functions.h mcuxClPrng_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClPkc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/src/: mcuxClPkc_Calculate.c mcuxClPkc_ImportExport.c mcuxClPkc_Initialize.c mcuxClPkc_UPTRT.c
  group component/els_pkc/src/comps/mcuxClPkc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/: mcuxClPkc.h mcuxClPkc_Functions.h mcuxClPkc_Types.h
  group component/els_pkc/src/comps/mcuxClPkc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPkc/inc/internal/: mcuxClPkc_ImportExport.h mcuxClPkc_FupMacros.h mcuxClPkc_Macros.h mcuxClPkc_Operations.h mcuxClPkc_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClEcc/src
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/src/: mcuxClEcc_Constants.c mcuxClEcc_EdDSA_GenerateKeyPair.c mcuxClEcc_EdDSA_GenerateKeyPair_FUP.c mcuxClEcc_EdDSA_GenerateSignature.c mcuxClEcc_EdDSA_Internal_SetupEnvironment.c mcuxClEcc_EdDSA_VerifySignature.c mcuxClEcc_Internal_BlindedScalarMult.c mcuxClEcc_Internal_Convert_FUP.c mcuxClEcc_Internal_GenerateMultiplicativeBlinding.c mcuxClEcc_Internal_Interleave_FUP.c mcuxClEcc_Internal_InterleaveTwoScalars.c mcuxClEcc_Internal_RecodeAndReorderScalar.c mcuxClEcc_Internal_SetupEnvironment.c mcuxClEcc_Internal_SetupEnvironment_FUP.c mcuxClEcc_Internal_Types.c mcuxClEcc_KeyTypes.c mcuxClEcc_Mont_DhKeyAgreement.c mcuxClEcc_Mont_DhKeyGeneration.c mcuxClEcc_Mont_Internal_DhSetupEnvironment.c mcuxClEcc_Mont_Internal_MontDhX.c mcuxClEcc_Mont_Internal_MontDhX_FUP.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder.c mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.c mcuxClEcc_SignatureMechanisms.c mcuxClEcc_TwEd_Internal_FixScalarMult.c mcuxClEcc_TwEd_Internal_PlainFixScalarMult25519.c mcuxClEcc_TwEd_Internal_PlainPtrSelectComb.c mcuxClEcc_TwEd_Internal_PlainPtrSelectML.c mcuxClEcc_TwEd_Internal_PlainVarScalarMult.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519.c mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.c mcuxClEcc_TwEd_Internal_PointValidation_FUP.c mcuxClEcc_TwEd_Internal_PrecPointImportAndValidate.c mcuxClEcc_TwEd_Internal_VarScalarMult.c mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.c mcuxClEcc_Weier_Internal_ConvertPoint_FUP.c mcuxClEcc_Weier_Internal_KeyGen.c mcuxClEcc_Weier_Internal_KeyGen_FUP.c mcuxClEcc_Weier_Internal_PointArithmetic.c mcuxClEcc_Weier_Internal_PointArithmetic_FUP.c mcuxClEcc_Weier_Internal_PointCheck.c mcuxClEcc_Weier_Internal_PointCheck_FUP.c mcuxClEcc_Weier_Internal_PointMult.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder.c mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.c mcuxClEcc_Weier_Internal_SetupEnvironment.c mcuxClEcc_Weier_KeyGen.c mcuxClEcc_Weier_PointMult.c mcuxClEcc_Weier_PointMult_FUP.c mcuxClEcc_Weier_Sign.c mcuxClEcc_Weier_Sign_FUP.c mcuxClEcc_Weier_Verify.c mcuxClEcc_Weier_Verify_FUP.c mcuxClEcc_WeierECC_Internal_GenerateCustomKeyType.c mcuxClEcc_WeierECC_Internal_GenerateDomainParams.c mcuxClEcc_WeierECC_Internal_GenerateDomainParams_FUP.c mcuxClEcc_WeierECC_Internal_SetupEnvironment.c
  group component/els_pkc/src/comps/mcuxClEcc/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClEcc/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/: mcuxClEcc.h mcuxClEcc_Constants.h mcuxClEcc_EdDSA_GenerateKeyPair_FUP.h mcuxClEcc_Functions.h mcuxClEcc_Internal_Convert_FUP.h mcuxClEcc_Internal_Interleave_FUP.h mcuxClEcc_Internal_SetupEnvironment_FUP.h mcuxClEcc_KeyMechanisms.h mcuxClEcc_MemoryConsumption.h mcuxClEcc_Mont_Internal_MontDhX_FUP.h mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.h mcuxClEcc_ParameterSizes.h mcuxClEcc_TwEd_Internal_PointArithmeticEd25519_FUP.h mcuxClEcc_TwEd_Internal_PointValidation_FUP.h mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.h mcuxClEcc_Types.h mcuxClEcc_Weier_Internal_ConvertPoint_FUP.h mcuxClEcc_Weier_Internal_KeyGen_FUP.h mcuxClEcc_Weier_Internal_PointArithmetic_FUP.h mcuxClEcc_Weier_Internal_PointCheck_FUP.h mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.h mcuxClEcc_Weier_PointMult_FUP.h mcuxClEcc_Weier_Sign_FUP.h mcuxClEcc_Weier_Verify_FUP.h mcuxClEcc_WeierECC.h mcuxClEcc_WeierECC_Internal_GenerateDomainParams_FUP.h
  group component/els_pkc/src/comps/mcuxClEcc/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClEcc/inc/internal/: mcuxClEcc_EdDSA_GenerateKeyPair_FUP.h mcuxClEcc_EdDSA_Internal.h mcuxClEcc_EdDSA_Internal_Hash.h mcuxClEcc_EdDSA_Internal_PkcWaLayout.h mcuxClEcc_Internal.h mcuxClEcc_Internal_Convert_FUP.h mcuxClEcc_Internal_Interleave_FUP.h mcuxClEcc_Internal_Random.h mcuxClEcc_Internal_SecurePointSelect.h mcuxClEcc_Internal_SetupEnvironment_FUP.h mcuxClEcc_Internal_UPTRT_access.h mcuxClEcc_Mont_Internal.h mcuxClEcc_Mont_Internal_MontDhX_FUP.h mcuxClEcc_Mont_Internal_PkcWaLayout.h mcuxClEcc_Mont_Internal_SecureScalarMult_XZMontLadder_FUP.h mcuxClEcc_TwEd_Internal.h mcuxClEcc_TwEd_Internal_Ed25519.h mcuxClEcc_TwEd_Internal_Ed25519_FUP.h mcuxClEcc_TwEd_Internal_PointValidation_FUP.h mcuxClEcc_TwEd_Internal_VarScalarMult_FUP.h mcuxClEcc_Weier_Internal.h mcuxClEcc_Weier_Internal_ConvertPoint_FUP.h mcuxClEcc_Weier_Internal_FP.h mcuxClEcc_Weier_Internal_KeyGen_FUP.h mcuxClEcc_Weier_Internal_PointArithmetic_FUP.h mcuxClEcc_Weier_Internal_PointCheck_FUP.h mcuxClEcc_Weier_Internal_SecurePointMult_CoZMontLadder_FUP.h mcuxClEcc_Weier_PointMult_FUP.h mcuxClEcc_Weier_Sign_FUP.h mcuxClEcc_Weier_Verify_FUP.h mcuxClEcc_WeierECC_Internal_DecodePoint_FUP.h mcuxClEcc_WeierECC_Internal_GenerateDomainParams.h mcuxClEcc_WeierECC_Internal_GenerateDomainParams_FUP.h
  group component/els_pkc/src/comps/mcuxClMath/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/src/: mcuxClMath_ExactDivide.c mcuxClMath_ExactDivideOdd.c mcuxClMath_ExactDivideOdd_FUP.c mcuxClMath_ModExp_SqrMultL2R.c mcuxClMath_ModInv.c mcuxClMath_ModInv_FUP.c mcuxClMath_NDash.c mcuxClMath_NDash_FUP.c mcuxClMath_QDash.c mcuxClMath_QDash_FUP.c mcuxClMath_ReduceModEven.c mcuxClMath_SecModExp.c mcuxClMath_SecModExp_FUP.c mcuxClMath_Utils.c
  group component/els_pkc/src/comps/mcuxClMath/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/: mcuxClMath.h mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Functions.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h mcuxClMath_Types.h
  group component/els_pkc/src/comps/mcuxClMath/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMath/inc/internal/: mcuxClMath_ExactDivideOdd_FUP.h mcuxClMath_Internal_ExactDivideOdd.h mcuxClMath_Internal_ModInv.h mcuxClMath_Internal_NDash.h mcuxClMath_Internal_QDash.h mcuxClMath_Internal_SecModExp.h mcuxClMath_Internal_Utils.h mcuxClMath_ModInv_FUP.h mcuxClMath_NDash_FUP.h mcuxClMath_QDash_FUP.h mcuxClMath_SecModExp_FUP.h
  group component/els_pkc/src/comps/mcuxClRsa/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/src/: mcuxClRsa_ComputeD.c mcuxClRsa_ComputeD_FUP.c mcuxClRsa_GenerateProbablePrime.c mcuxClRsa_KeyGeneration_Crt.c mcuxClRsa_KeyGeneration_Crt_FUP.c mcuxClRsa_KeyGeneration_Plain.c mcuxClRsa_Mgf1.c mcuxClRsa_MillerRabinTest.c mcuxClRsa_MillerRabinTest_FUP.c mcuxClRsa_ModInv.c mcuxClRsa_NoEncode.c mcuxClRsa_NoVerify.c mcuxClRsa_Pkcs1v15Encode_sign.c mcuxClRsa_Pkcs1v15Verify.c mcuxClRsa_PrivateCrt.c mcuxClRsa_PrivateCrt_FUP.c mcuxClRsa_PrivatePlain.c mcuxClRsa_PrivatePlain_FUP.c mcuxClRsa_PssEncode.c mcuxClRsa_PssVerify.c mcuxClRsa_Public.c mcuxClRsa_Public_FUP.c mcuxClRsa_Sign.c mcuxClRsa_TestPQDistance.c mcuxClRsa_TestPQDistance_FUP.c mcuxClRsa_TestPrimeCandidate.c mcuxClRsa_TestPrimeCandidate_FUP.c mcuxClRsa_Verify.c mcuxClRsa_VerifyE.c
  group component/els_pkc/src/comps/mcuxClRsa/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClRsa/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/: mcuxClRsa.h mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Constants.h mcuxClRsa_Functions.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MemoryConsumption.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_PrivatePlain_FUP.h mcuxClRsa_Public_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h mcuxClRsa_Types.h
  group component/els_pkc/src/comps/mcuxClRsa/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRsa/inc/internal/: mcuxClRsa_ComputeD_FUP.h mcuxClRsa_Internal_Functions.h mcuxClRsa_Internal_Macros.h mcuxClRsa_Internal_MemoryConsumption.h mcuxClRsa_Internal_PkcDefs.h mcuxClRsa_Internal_Types.h mcuxClRsa_KeyGeneration_Crt_FUP.h mcuxClRsa_MillerRabinTest_FUP.h mcuxClRsa_PrivateCrt_FUP.h mcuxClRsa_PrivatePlain_FUP.h mcuxClRsa_Public_FUP.h mcuxClRsa_TestPQDistance_FUP.h mcuxClRsa_TestPrimeCandidate_FUP.h
  group component/els_pkc/src/comps/mcuxClRandom/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/src/: mcuxClRandom_DRBG.c mcuxClRandom_PRNG.c
  group component/els_pkc/src/comps/mcuxClRandom/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/: mcuxClRandom.h mcuxClRandom_Constants.h mcuxClRandom_Functions.h mcuxClRandom_Types.h
  group component/els_pkc/src/comps/mcuxClRandom/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandom/inc/internal/: mcuxClRandom_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClCore/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCore/inc/: mcuxClCore_Analysis.h mcuxClCore_Buffer.h mcuxClCore_Examples.h mcuxClCore_FunctionIdentifiers.h mcuxClCore_Platform.h mcuxClCore_Toolchain.h
  group component/els_pkc/src/comps/mcuxClPadding/src
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/src/: mcuxClPadding.c
  group component/els_pkc/src/comps/mcuxClPadding/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/: mcuxClPadding.h mcuxClPadding_Constants.h mcuxClPadding_Types.h
  group component/els_pkc/src/comps/mcuxClPadding/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClPadding/inc/internal/: mcuxClPadding_Functions_Internal.h mcuxClPadding_Internal.h mcuxClPadding_Types_Internal.h
  group component/els_pkc/src/comps/mcuxClCipher/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/src/: mcuxClCipher.c
  group component/els_pkc/src/comps/mcuxClCipher/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/: mcuxClCipher.h mcuxClCipher_Constants.h mcuxClCipher_Functions.h mcuxClCipher_Types.h
  group component/els_pkc/src/comps/mcuxClCipher/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipher/inc/internal/: mcuxClCipher_Internal.h mcuxClCipher_Internal_Constants.h mcuxClCipher_Internal_Functions.h mcuxClCipher_Internal_Types.h
  group component/els_pkc/src/comps/mcuxClCipherModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/src/: mcuxClCipherModes_ELS_Aes.c mcuxClCipherModes_ELS_EngineAes.c mcuxClCipherModes_Helper.c mcuxClCipherModes_Modes.c
  group component/els_pkc/src/comps/mcuxClCipherModes/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClCipherModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/: mcuxClCipherModes.h mcuxClCipherModes_MemoryConsumption.h mcuxClCipherModes_Modes.h
  group component/els_pkc/src/comps/mcuxClCipherModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClCipherModes/inc/internal/: mcuxClCipherModes_Algorithms.h mcuxClCipherModes_Internal.h mcuxClCipherModes_Internal_Constants.h mcuxClCipherModes_Internal_Functions.h mcuxClCipherModes_Internal_Types.h mcuxClCipherModes_Wa.h
  group component/els_pkc/src/comps/mcuxClAead/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/src/: mcuxClAead.c
  group component/els_pkc/src/comps/mcuxClAead/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/: mcuxClAead.h mcuxClAead_Constants.h mcuxClAead_Functions.h mcuxClAead_Types.h
  group component/els_pkc/src/comps/mcuxClAead/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAead/inc/internal/: mcuxClAead_Internal_Ctx.h mcuxClAead_Internal_Descriptor.h
  group component/els_pkc/src/comps/mcuxClAeadModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/src/: mcuxClAeadModes_ELS_AesCcm.c mcuxClAeadModes_ELS_AesGcm.c mcuxClAeadModes_ELS_CcmEngineAes.c mcuxClAeadModes_ELS_Constants.c mcuxClAeadModes_ELS_GcmEngineAes.c mcuxClAeadModes_ELS_MultiPart.c mcuxClAeadModes_ELS_OneShot.c
  group component/els_pkc/src/comps/mcuxClAeadModes/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClAeadModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/: mcuxClAeadModes.h mcuxClAeadModes_MemoryConsumption.h mcuxClAeadModes_Modes.h
  group component/els_pkc/src/comps/mcuxClAeadModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClAeadModes/inc/internal/: mcuxClAeadModes_Common_Functions.h mcuxClAeadModes_ELS_Functions.h mcuxClAeadModes_ELS_Types.h mcuxClAeadModes_Internal.h mcuxClAeadModes_Internal_Constants.h
  group component/els_pkc/src/comps/mcuxClRandomModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/src/: mcuxClRandomModes_CtrDrbg.c mcuxClRandomModes_CtrDrbg_Els.c mcuxClRandomModes_CtrDrbg_PrDisabled.c mcuxClRandomModes_ElsMode.c mcuxClRandomModes_NormalMode.c mcuxClRandomModes_PrDisabled.c
  group component/els_pkc/src/comps/mcuxClRandomModes/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClRandomModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/: mcuxClRandomModes.h mcuxClRandomModes_Constants.h mcuxClRandomModes_Functions_PatchMode.h mcuxClRandomModes_Functions_TestMode.h mcuxClRandomModes_MemoryConsumption.h
  group component/els_pkc/src/comps/mcuxClRandomModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClRandomModes/inc/internal/: mcuxClRandomModes_Internal_SizeDefinitions.h mcuxClRandomModes_Private_CtrDrbg.h mcuxClRandomModes_Private_CtrDrbg_BlockCipher.h mcuxClRandomModes_Private_Drbg.h mcuxClRandomModes_Private_NormalMode.h mcuxClRandomModes_Private_PrDisabled.h
  group component/els_pkc/src/comps/mcuxClTrng/src
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/src/: mcuxClTrng_ELS.c
  group component/els_pkc/src/comps/mcuxClTrng/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClTrng/inc/internal/: mcuxClTrng_Internal.h mcuxClTrng_Internal_Constants.h mcuxClTrng_Internal_Functions.h mcuxClTrng_Internal_Types.h mcuxClTrng_SfrAccess.h
  group component/els_pkc/src/comps/mcuxClMacModes/src
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/src/: mcuxClMacModes.c mcuxClMacModes_ELS_Aes.c mcuxClMacModes_ELS_CBCMAC.c mcuxClMacModes_ELS_CMAC.c mcuxClMacModes_ELS_HMAC.c mcuxClMacModes_Helper.c mcuxClMacModes_Modes.c
  group component/els_pkc/src/comps/mcuxClMacModes/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClMacModes/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/: mcuxClMacModes.h mcuxClMacModes_Constants.h mcuxClMacModes_Functions.h mcuxClMacModes_MemoryConsumption.h mcuxClMacModes_Modes.h
  group component/els_pkc/src/comps/mcuxClMacModes/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClMacModes/inc/internal/: mcuxClMacModes_Algorithms.h mcuxClMacModes_ELS_CBCMAC.h mcuxClMacModes_ELS_CMAC.h mcuxClMacModes_ELS_Ctx.h mcuxClMacModes_ELS_HMAC.h mcuxClMacModes_ELS_Types.h mcuxClMacModes_Internal_Constants.h mcuxClMacModes_Internal_Functions.h mcuxClMacModes_Internal_Types.h mcuxClMacModes_Wa.h
  group component/els_pkc/src/comps/mcuxClOsccaSm3/src
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/src/: mcuxClOsccaSm3_common.c mcuxClOsccaSm3_core_sm3.c mcuxClOsccaSm3_internal_sm3.c
  group component/els_pkc/src/comps/mcuxClOsccaSm3/src/size
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/src/size/: size.c
  group component/els_pkc/src/comps/mcuxClOsccaSm3/inc
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/: mcuxClOsccaSm3.h mcuxClOsccaSm3_Algorithms.h mcuxClOsccaSm3_Constants.h mcuxClOsccaSm3_MemoryConsumption.h
  group component/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal
    ../../../../../../components/els_pkc/src/comps/mcuxClOsccaSm3/inc/internal/: mcuxClOsccaSm3_Core_sm3.h mcuxClOsccaSm3_Internal.h mcuxClOsccaSm3_Internal_sm3.h mcuxClOsccaSm3_SfrAccess.h
  group component/els_pkc/src/comps/common/inc
    ../../../../../../components/els_pkc/src/comps/common/inc/: mcuxClOscca_FunctionIdentifiers.h mcuxClOscca_Memory.h mcuxClOscca_PlatformTypes.h mcuxClOscca_Types.h
target els_pkc_asymmetric release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: els_pkc_asymmetric.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: as above
