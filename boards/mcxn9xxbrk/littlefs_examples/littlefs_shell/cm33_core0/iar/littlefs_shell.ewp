# IAR project littlefs_shell.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=2147483648; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../components/flash/mflash/mcxnx4x_flexspi; ../../../../../../devices/MCXN947/drivers; ../../../../../../middleware/littlefs; ../../../../../../devices/MCXN947/utilities; ../../../../../../devices/MCXN947; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../devices/MCXN947/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../components/flash/mflash; ../../../../../../devices/MCXN947/drivers/romapi/flash; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: littlefs_shell.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; LFS_NO_INTRINSICS=1; SDK_DEBUGCONSOLE_UART; MFLASH_FILE_BASEADDR=2147483648; DEBUG_CONSOLE_RX_ENABLE=0; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: littlefs_shell.c lfs_mflash.c lfs_mflash.h
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group flash/mflash
    ../../../../../../components/flash/mflash/: mflash_common.h
  group flash/mflash/mcxnx4x_flexspi
    ../../../../../../components/flash/mflash/mcxnx4x_flexspi/: mflash_drv.c mflash_drv.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_port.h fsl_flexspi.c fsl_flexspi.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group drivers/flash
    ../../../../../../devices/MCXN947/drivers/romapi/flash/: fsl_flash.h fsl_efuse.h fsl_flash_ffr.h fsl_flexspi_nor_flash.h
  group drivers/flash/src
    ../../../../../../devices/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
  group littlefs
    ../../../../../../middleware/littlefs/: lfs.c lfs_util.c lfs.h lfs_util.h
  group utilities
    ../../../../../../devices/MCXN947/utilities/: fsl_shell.c fsl_shell.h fsl_assert.c
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXN947/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
