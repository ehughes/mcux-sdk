# Keil uVision project runbootloader.uvprojx, settings and files
target runbootloader debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: runbootloader.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MCXN947/utilities/str;../../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../../devices/MCXN947/drivers/romapi/mem_interface;../../../../../../../devices/MCXN947/drivers/romapi/flash;../../../../../../../devices/MCXN947/drivers/romapi/nboot;../../../../../../../devices/MCXN947/drivers/romapi/runbootloader;../../../../../../../devices/MCXN947/drivers;../../../../../../../devices/MCXN947;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ../: runbootloader.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers/mem_interface
    ../../../../../../../devices/MCXN947/drivers/romapi/mem_interface/: fsl_mem_interface.h fsl_sbloader.h fsl_sbloader_v3.h
  group drivers/flash
    ../../../../../../../devices/MCXN947/drivers/romapi/flash/: fsl_flash.h fsl_flash_ffr.h fsl_flexspi_nor_flash.h
  group drivers/nboot
    ../../../../../../../devices/MCXN947/drivers/romapi/nboot/: fsl_nboot.h fsl_nboot_hal.h
  group drivers/runbootloader
    ../../../../../../../devices/MCXN947/drivers/romapi/runbootloader/: fsl_runbootloader.h
  group drivers/runbootloader/src
    ../../../../../../../devices/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target runbootloader release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: runbootloader.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler
