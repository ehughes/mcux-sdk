# Keil uVision project powerquad_benchmark_sw_matrix.uvprojx, settings and files
target powerquad_benchmark_sw_matrix debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: powerquad_benchmark_sw_matrix.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, DISABLEFLOAT16, MCUXPRESSO_SDK
  c misc: -Wno-gcc-compat  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/MCXN947/utilities/str;../../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../../devices/MCXN947/drivers;../../../../../../../CMSIS/DSP/Include;../../../../../../../CMSIS/DSP/PrivateInclude;../../../../../../../CMSIS/DSP/Source/DistanceFunctions;../../../../../../../devices/MCXN947;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x8000"
  group source
    ../: powerquad_benchmark_sw_matrix.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_inputmux.h fsl_inputmux.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_inputmux_connections.h
  group CMSIS/DSP/Include
    ../../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target powerquad_benchmark_sw_matrix release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: powerquad_benchmark_sw_matrix.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, DISABLEFLOAT16, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: as above
