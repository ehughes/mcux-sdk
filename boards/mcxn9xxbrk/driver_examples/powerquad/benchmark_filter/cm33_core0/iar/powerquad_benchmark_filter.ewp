# IAR project powerquad_benchmark_filter.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MCXN947/utilities/str; ../../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../../devices/MCXN947/drivers; ../../../../../../../devices/MCXN947; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/DSP/Include; ../../../../../../../CMSIS/DSP/PrivateInclude
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: powerquad_benchmark_filter.out
  ILINK.IlinkConfigDefines: __stack_size__=0x8000
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: powerquad_benchmark_filter.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MCXN947/drivers/: fsl_clock.h fsl_clock.c fsl_powerquad_data.h fsl_powerquad_data.c fsl_powerquad.h fsl_powerquad_basic.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_filter.c fsl_powerquad_transform.c fsl_powerquad.h fsl_powerquad_cmsis.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_inputmux.h fsl_inputmux.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_inputmux_connections.h
  group device
    ../../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group CMSIS/DSP/Include
    ../../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
