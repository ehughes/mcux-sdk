# Keil uVision project freertos_tickless.uvprojx, settings and files
target freertos_tickless debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: freertos_tickless.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../low_power_tickless/cm33_core0;..;../../../../../../devices/MCXN947/utilities/str;../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../devices/MCXN947/drivers;../../../../../../devices/MCXN947;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/Core/Include;../../../../../../rtos/freertos/freertos-kernel/include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler
  group source/low_power_tickless
    ../../low_power_tickless/cm33_core0/: fsl_tickless_lptmr.c fsl_tickless_lptmr.h
  group source
    ../: freertos_tickless.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_lptmr.c fsl_lptmr.h fsl_wuu.c fsl_wuu.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_pint.h fsl_pint.c fsl_inputmux.h fsl_inputmux.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_lpuart.h fsl_lpuart.c fsl_reset.h fsl_reset.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_inputmux_connections.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group startup
    ../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
target freertos_tickless release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: freertos_tickless.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, SDK_OS_FREE_RTOS, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler
